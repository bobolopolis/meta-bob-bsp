SUMMARY = "Empty image for use when the main image is an initramfs"
LICENSE = "MIT"

PACKAGE_INSTALL = ""

inherit core-image
